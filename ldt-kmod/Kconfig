## ldt-kmod/Kconfig
```kconfig
#
# ldt configuration
#
config LDT
        tristate "ldt"
        ---help---
          LDT is a (mp-)dccp tunnel in kernel space.
```
